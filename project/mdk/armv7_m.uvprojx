# Keil uVision project armv7_m.uvprojx, settings and files
target armv7_m (6180000::V6.18::ARMCLANG)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.16.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: armv7_m +hex
  group boot
    ../../boot/: init.S
  group include
    ../../include/asm/: arch_atomic.h arch_coprocessor .h arch_feature.h arch_nvic.h arch_printk.h arch_regs.h arch_systick.h barrier.h cache.h context_stack.h gcc_type.h irqflags.h mpu.h traps.h vfp.h arch_config.h
    ../../lib/include/: ring_buffer.h math_util.h
  group kernel
    ../../kernel/: arch_init.c early_printk.c traps.c
  group mm
    ../../mm/: cache.c mm_fault.c mpu.c
  group lib
    ../../lib/: ring_buffer.c math_util.c
  group test
    ../../test/: main.c early_printk_test.c mpu_test.c mm_fault_test.c trap_test.c
